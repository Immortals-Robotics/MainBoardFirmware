# Keil uVision project Firmware.uvprojx, settings and files
target nrf52832_xxaa (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 BSP_DEFINES_ONLY NRF52 NRF52832_XXAA NRF52_PAN_74
  c misc: --reduce_paths
  c include: src\components;src\components\boards;src\components\proprietary_rf\esb;src\components\drivers_nrf\common;src\components\drivers_nrf\delay;src\components\drivers_nrf\hal;src\components\drivers_nrf\nrf_soc_nosd;src\components\drivers_nrf\uart;src\components\drivers_nrf\saadc;src\components\drivers_nrf\ppi;src\components\drivers_nrf\timer;src\components\drivers_nrf\spi_master;src\components\libraries\atomic;src\components\libraries\balloc;src\components\libraries\bsp;src\components\libraries\experimental_log;src\components\libraries\experimental_log\src;src\components\libraries\experimental_memobj;src\components\libraries\experimental_section_vars;src\components\libraries\fifo;src\components\libraries\strerror;src\components\libraries\uart;src\components\libraries\util;.\src\external\RTT;.\src\config;.\src\core
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    src/: main.c
    src/config/: sdk_config.h
    src/core/: my_UART.h my_esb_RF.h my_ADC.h Process.h
  group Board Definition
    src/components/boards/: boards.c
  group nRF_Drivers
    src/components/drivers_nrf/common/: nrf_drv_common.c
    src/components/drivers_nrf/uart/: nrf_drv_uart.c
    src/components/drivers_nrf/spi_master/: nrf_drv_spi.c
  group nRF_Libraries
    src/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    src/components/libraries/fifo/: app_fifo.c
    src/components/libraries/uart/: app_uart_fifo.c retarget.c
    src/components/libraries/balloc/: nrf_balloc.c
    src/components/libraries/experimental_memobj/: nrf_memobj.c
    src/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    src/components/libraries/experimental_log/src/: nrf_log_frontend.c
  group nRF_Properitary_RF
    src/components/proprietary_rf/esb/: nrf_esb.c
  group ADC_Read
    src/components/drivers_nrf/hal/: nrf_saadc.c nrf_saadc.h
  group nRF_Segger_RTT
    src/external/segger_rtt/: SEGGER_RTT.c RTT_Syscalls_KEIL.c
    src/external/RTT/: SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.14.1
